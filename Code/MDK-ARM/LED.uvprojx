# Keil uVision project LED.uvprojx, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../LCD;../oled_Int;../lvgl;../lvgl/GUI/lvgl;../lvgl/GUI/lvgl/examples/porting;../lvgl/GUI/lvgl/src;../lvgl/GUI;../FreeRTOS;../FreeRTOS/portable/MemMang;../FreeRTOS/portable/RVDS/ARM_CM4F;../FreeRTOS/include;../FreeRTOS/SYSTEM/delay;../FreeRTOS/SYSTEM/sys;../FreeRTOS/SYSTEM/usart;../lvgl/lvgl_demo;../CST816T;../lvgl/img;../lvgl/GUI_APP/demos/widgets;../lvgl/GUI_APP/demos/widgets/assets;../W25Q64;../RTC;../font;../Mpu6050;../wallpaper;../DNAWALLPAPER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Core/Inc/: FreeRTOSConfig.h
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ./: startup_stm32f411xe.s
    ../Core/Src/: system_stm32f4xx.c
  group LCD
    ../LCD/: delay.c delay.h lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h sys.c sys.h
  group led
    ../oled_Int/: OLED.c OLED.h OLED_Font.h
  group LVGL_conf
    ../lvgl/GUI/lvgl/: lv_conf.h lvgl.h
  group LVGL_example
    ../lvgl/GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group FREEROTS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FREEROTS_PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FREEROTS_SYS
    ../FreeRTOS/SYSTEM/delay/: FREE_DELAY.c FREE_DELAY.h
    ../FreeRTOS/SYSTEM/sys/: FREE_SYS.c FREE_SYS.h
    ../FreeRTOS/SYSTEM/usart/: FREE_USART.c FREE_USART.h
  group lvgl_demo
    ../lvgl/lvgl_demo/: lvgl_demo.c lvgl_demo.h
  group LVGL_src
    ../lvgl/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lvgl/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../lvgl/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lvgl/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lvgl/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../lvgl/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../lvgl/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lvgl/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../lvgl/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../lvgl/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../lvgl/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../lvgl/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../lvgl/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../lvgl/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../lvgl/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../lvgl/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lvgl/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../lvgl/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../lvgl/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../lvgl/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../lvgl/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../lvgl/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lvgl/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../lvgl/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../lvgl/GUI/lvgl/src/extra/: lv_extra.c
    ../lvgl/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../lvgl/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../lvgl/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_moon
    ../lvgl/GUI/lvgl/src/LIChen/: moon.c moon1.c moon2.c moon3.c moon4.c moon5.c moon6.c moon7.c moon8.c moon9.c moon10.c moon11.c moon12.c moon13.c wl.c
  group CST816T
    ../CST816T/: CST816T.c CST816T.h
  group img
    ../lvgl/img/: about.c Calculator.c calendar.c compass.c dimensional.c environment.c SET.c stopwatch.c wallper.c rocket.c step.c temperature.c TKR.c TKR1.c TKR2.c TKR3.c TKR4.c TKR12.c TKR13.c TKR14.c TKR15.c alarm_clock.c indicator.c indicator2.c dial.c
  group W25Q64
    ../W25Q64/: W25Q64_Ins.h W25Q64.h W25Q64.c MySPI.h MySPI.c
  group RTC
    ../RTC/: MyI2C.c MyI2C.h PCF8563.c PCF8563.h
  group font
    ../font/: lv_font_30 .c playlist.c Facon.c league.c Italic.c HEITi_14.c HEITi_16.c Time.c Dyh.c Sun.c Lightbulb.c playist.c Welcome.c LWatch.c MIAObiao.c MIAObiaoZS.c TIMEAppear.c Clock.c Hand.c Display.c Password.c TIME_Appear_sec.c MIAOBiao_msec.c Setting_HZ.c password_show.c Environment_HZ.c LIGHT_hz.c ComPass.c tic_tac.c Game_HZ.c
  group mpu6050
    ../Mpu6050/: mpu6050.c mpu6050.h MPU6050_I2C.c MPU6050_I2C.h BME280.c BME280.h HMC.c HMC.h
  group wallpaper
    ../wallpaper/: YJ.c SpiderMan.c BrilliantEye.c CURRY.c Five.c flower.c GTX.c HYRZ.c JERRY.c JUSTDO.c LZ.c M.c money.c NAME.c PDXHM.c snow.c spider.c APERTURE.c Demon.c DT.c
  group dna Wallpaper
    ../DNA WALLPAPER/: HYRE1.c HYRZ2.c HYRZ3.c HYRZ4.c HYRZ6.c HYRZ7.c HYRZ8.c HYRZ9.c
software components: CMSIS:CORE 5.6.0
